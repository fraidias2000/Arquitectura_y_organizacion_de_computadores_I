# Keil uVision project Practica1.uvproj, settings and files
target Practica1 (ARM-ADS)
  device: LPC2104 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Practica1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\practica1.sct
  group Practica1
    ./: practica1.s
