LR_IRAM1 0x400000 0x10000  {  ; load region
 ER_IRAM1 0x400000 {  ; RW data
   * (+RO +RW +ZI)
 }
}